PLATFORM = "hamoa"
PBT_BUILD_DATE = "260616"

require common.inc

SRC_URI[camxlib.sha256sum] = "fa862d980478564abb2c8efff81e2783cd1269cc4d38cb215f9a1e2d02e23269"
SRC_URI[camx.sha256sum] = "1b59111f0ef43bb96d2fed3e189108d8b6027672268bd03747121d7d6bc0385e"
SRC_URI[chicdk.sha256sum] = "c20d1b44137eb3cf69cda234ece46be1b0b3bc41acf3940eb4000ec49c0efce5"
SRC_URI[camxcommon.sha256sum] = "c1c54b93e1844dc27e5467fef941fa7ba8d41b53417d15526a27c60840630d58"
