require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "4e4fe94a4dad8a31319b6e1aca28d089f8a363db81aaf0bb3ef8fc8c6e7d187b"
