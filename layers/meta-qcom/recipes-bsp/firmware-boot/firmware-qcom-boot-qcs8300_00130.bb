require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "e202c36dd5b5dcb81a3014dca3cafaef0044d71dda5e3a8adbb355655b4b2a81"
