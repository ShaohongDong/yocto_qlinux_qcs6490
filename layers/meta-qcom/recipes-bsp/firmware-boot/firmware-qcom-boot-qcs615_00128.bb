require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "541e9439e34a8910fca6f12b0141f57001a278bf48b386662869aebba20b216b"
