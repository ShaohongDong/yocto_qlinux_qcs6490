require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "a322c3a2abae3376c0bb8b01daf3e50827f87cf0abbe6a29a0c8e410f9db002a"
