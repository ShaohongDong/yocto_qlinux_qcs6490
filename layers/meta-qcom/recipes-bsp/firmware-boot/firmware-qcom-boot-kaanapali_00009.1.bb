require firmware-qcom-boot-kaanapali.inc

SRC_URI[bootbinaries.sha256sum] = "87b72830fd06ffd08ebc211301a254f4ef46325fde75bb6ff82ac558a5c26b12"
