require firmware-qcom-boot-glymur.inc

SRC_URI[bootbinaries.sha256sum] = "bcc25ba8ac20b759d6068bf127af2aa0f8fccb08ea130a251dcdc6101123edc1"
