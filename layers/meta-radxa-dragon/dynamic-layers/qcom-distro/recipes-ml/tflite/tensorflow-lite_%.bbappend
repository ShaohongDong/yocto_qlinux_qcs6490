DEPENDS:remove:qcom = "protobuf protobuf-native"
DEPENDS:append:qcom = " protobuf-camx protobuf-camx-native"
