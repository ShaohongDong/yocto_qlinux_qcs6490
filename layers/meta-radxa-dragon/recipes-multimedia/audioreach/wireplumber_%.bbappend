# SPDX-License-Identifier: MIT
PACKAGECONFIG:remove:radxa-dragon-q6a = "systemd-system-service"
PACKAGE_ARCH:radxa-dragon-q6a = "${MACHINE_ARCH}"
