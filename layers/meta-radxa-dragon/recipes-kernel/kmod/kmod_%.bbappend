# SPDX-License-Identifier: MIT
# Both image-time depmod and target modprobe must understand .ko.zst modules.
PACKAGECONFIG:append = " zstd"
