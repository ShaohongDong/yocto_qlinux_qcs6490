# SPDX-License-Identifier: MIT
SRC_URI:append:radxa-dragon-q6a = " file://0004-gbm-preserve-live-device-handles.patch"
