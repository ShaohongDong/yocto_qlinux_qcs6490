# SPDX-License-Identifier: MIT
inherit qcom-imx708-image-gate
