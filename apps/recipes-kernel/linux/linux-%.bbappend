inherit qcom-app-kernel
